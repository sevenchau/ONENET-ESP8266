# IAR project coxtexm4_bs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; ..\; ..\utilities_lib; ..\app\; ..\app\app_utilities; ..\app\app_user; ..\hal_bsp\hal_stCotexM4\startup\IAR; ..\hal_bsp\hal_stCotexM4\STM32F4_HAL_lib\inc; ..\hal_bsp\bsp_Utilities; ..\hal_bsp\bsp_STMB997; ..\hal_bsp\CMSIS; ..\middleware_os\lib_ucosiii\uC-CPU; ..\middleware_os\lib_ucosiii\uC-CPU\ARM-Cortex-M4\IAR; ..\middleware_os\lib_ucosiii\uC-LIB; ..\middleware_os\lib_ucosiii\uC-LIB\Ports\ARM-Cortex-M4\IAR; ..\middleware_os\lib_ucosiii\uCOS-III\Ports\ARM-Cortex-M4; ..\middleware_os\lib_ucosiii\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\middleware_os\lib_ucosiii\uCOS-III\Source; ..\middleware_os\driver; ..\middleware_os\mid_utilities; ..\middleware_os\mid_utilities\http; ..\middleware_os\mid_utilities\edp; ..\middleware_os\mid_utilities\modbus; ..\middleware_os\mid_utilities\mqtt
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: coxtexm4_bs.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: E:\001SVN_zkhData\001BoLen\005BL_basestation\001BL_basestation\bl_bs\hal_bsp\hal_stCotexM4\startup\IAR\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group (top)
    ./: readme.md
  group app_usr
    ../app/: app_cfg.h main.c os_app_hooks.c ser_data_acq.c ser_net.c
  group app_usr/inc
    ../app/app_user/: cpu_cfg.h includes.h lib_cfg.h os_app_hooks.h os_cfg.h os_cfg_app.h stm32f4xx.h stm32f4xx_conf.h
  group hal/bspMB997
    ../hal_bsp/bsp_STMB997/: bsp.c bsp.h bsp_gpio.c bsp_int.c bsp_periph.c bsp_private.h bsp_spi.c bsp_usart.c
  group hal/hal_utilities
    ../hal_bsp/bsp_Utilities/: hal_utilities.c hal_utilities.h
  group hal/startup/IAR
    ../hal_bsp/hal_stCotexM4/startup/IAR/: cstartup.c
  group hal/STM32F4_lib/src
    ../hal_bsp/hal_stCotexM4/STM32F4_HAL_lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group mid_layer/driver
    ../middleware_os/driver/: dr.c dr_dht11.c dr_inc.h dr_led.c dr_private.h dr_wifi.c
  group mid_layer/mid_utilities
    ../middleware_os/mid_utilities/: cJSON.c cJSON.h Common.h mem_malloc.c mem_malloc.h
    ../middleware_os/mid_utilities/edp/: edp.c EdpKit.c EdpKit.h
  group mid_layer/os/uC/CPU
    ../middleware_os/lib_ucosiii/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group mid_layer/os/uC/CPU/ARM-Cortex-M4/IAR
    ../middleware_os/lib_ucosiii/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
  group mid_layer/os/uC/LIB
    ../middleware_os/lib_ucosiii/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group mid_layer/os/uC/LIB/Ports/ARM-Cortex-M4/IAR
    ../middleware_os/lib_ucosiii/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group mid_layer/os/uC/OS-III/Ports/ARM-Cortex-M4/Generic/IAR
    ../middleware_os/lib_ucosiii/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group mid_layer/os/uC/OS-III/Source
    ../middleware_os/lib_ucosiii/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
